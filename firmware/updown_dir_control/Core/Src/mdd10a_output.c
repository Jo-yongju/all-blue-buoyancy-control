#include "main.h"
#include "live_io.h"
#include "live_config.h"
#include <math.h>

static int direction[2];
static uint32_t off_since[2];

void LiveIO_Off(void)
{
    if (!(RCC->APB1ENR1 & RCC_APB1ENR1_TIM4EN)) return;
    TIM4->CCR1=TIM4->CCR4=0;
    TIM4->CCER=0;
    direction[0]=direction[1]=0;
    off_since[0]=off_since[1]=HAL_GetTick();
}

void LiveIO_InitOutputs(void)
{
    __HAL_RCC_GPIOB_CLK_ENABLE(); __HAL_RCC_GPIOC_CLK_ENABLE();
    __HAL_RCC_TIM4_CLK_ENABLE(); __HAL_RCC_TIM4_FORCE_RESET(); __HAL_RCC_TIM4_RELEASE_RESET();
    LiveIO_Off();
    GPIOC->BSRR=(GPIO_PIN_4|GPIO_PIN_7)<<16;
    GPIO_InitTypeDef p={.Pin=GPIO_PIN_4|GPIO_PIN_7,.Mode=GPIO_MODE_OUTPUT_PP,.Pull=GPIO_PULLDOWN};
    HAL_GPIO_Init(GPIOC,&p);
    p.Pin=GPIO_PIN_6|GPIO_PIN_9; p.Mode=GPIO_MODE_AF_PP; p.Alternate=GPIO_AF2_TIM4;
    HAL_GPIO_Init(GPIOB,&p);
    uint32_t clk=HAL_RCC_GetPCLK1Freq();
    if (RCC->CFGR&RCC_CFGR_PPRE1) clk*=2;
    TIM4->PSC=clk/1000000U-1; TIM4->ARR=999;
    TIM4->CCMR1=TIM_CCMR1_OC1M_1|TIM_CCMR1_OC1M_2;
    TIM4->CCMR2=TIM_CCMR2_OC4M_1|TIM_CCMR2_OC4M_2;
    TIM4->EGR=TIM_EGR_UG; TIM4->CR1=TIM_CR1_CEN;
    __HAL_DBGMCU_FREEZE_TIM4();
}

/* Common hardware writer for timed JOG, position and dual-axis angle control.
 * PWM is generated by TIM4 hardware; updating registers never waits for motion. */
static void WriteChannel(unsigned axis, float duty, int sign)
{
    volatile uint32_t *ccr=axis?&TIM4->CCR4:&TIM4->CCR1;
    uint32_t bit=axis?TIM_CCER_CC4E:TIM_CCER_CC1E;
    uint32_t pin=axis?GPIO_PIN_7:GPIO_PIN_4;
    if (!sign || !isfinite(duty) || duty<=0) {
        *ccr=0; TIM4->CCER &= ~bit; direction[axis]=0;
        return;
    }
    GPIOC->BSRR=sign>0?pin:pin<<16;
    *ccr=(uint32_t)lroundf((TIM4->ARR+1U)*fminf(duty,1.0f));
    TIM4->CCER |= bit; direction[axis]=sign;
}

void LiveIO_SingleWrite(unsigned axis,int percent)
{
    if (!(RCC->APB1ENR1 & RCC_APB1ENR1_TIM4EN)) return;
    if (axis>1 || percent < -100 || percent>100) { LiveIO_Off(); return; }
    WriteChannel(1U-axis,0,0); /* Never leave the unused bench motor energized. */
    WriteChannel(axis,fabsf((float)percent)/100.0f,(percent>0)-(percent<0));
}

/* Caller holds IRQ mask and has rechecked the stop generation. */
void LiveIO_Write(float front,float rear,uint32_t now)
{
    float u[]={front,rear};
    for(unsigned i=0;i<2;i++){
        volatile uint32_t *ccr=i?&TIM4->CCR4:&TIM4->CCR1;
        uint32_t bit=i?TIM_CCER_CC4E:TIM_CCER_CC1E;
        int d=(u[i]>0)-(u[i]<0);
        if (direction[i] && direction[i]!=d) {
            TIM4->CCER &= ~bit; *ccr=0; direction[i]=0; off_since[i]=now; continue;
        }
        if (!d || (!direction[i] && now-off_since[i]<100)) {
            TIM4->CCER &= ~bit; *ccr=0; continue;
        }
        WriteChannel(i,fminf(fabsf(u[i]),live_cfg.pwm_limit),d);
    }
}

/* Caller holds IRQ mask, checks ARM, and enforces the 100ms restart gap.
 * Unlike LIVE, this timed bench command uses the explicitly requested duty.
 * Disable both channels first so selecting another motor cannot leave one on. */
void LiveIO_Jog(unsigned axis, int percent)
{
    LiveIO_Off();
    LiveIO_SingleWrite(axis,percent);
}
